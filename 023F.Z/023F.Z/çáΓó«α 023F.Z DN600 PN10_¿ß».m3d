# KOMPAS-3D part "Затвор 023F.Z DN600 PN10 под исполнительный механизм" (çáΓó«α 023F.Z DN600 PN10_¿ß».m3d)
File: written by KOMPAS-3D 19.0; created 27.04.2026 16:22:09, last saved 27.04.2026 16:22:09.

Document properties: Автор: Евгений; Полное имя файла: Z:\3.Личные\kachalov\3d для проектировщиков\1.7 Тип 023F.Z Затвор дисковый поворотный фланцевый с двумя эксцентриками\Затвор 023F.Z DN200-DN1600_исп\_stp_Затвор 023F.Z DN200-DN1600_исп\Затвор 023F.Z DN600 PN10_исп.m3d

Product:
- Part/product: Затвор 023F.Z DN600 PN10 под исполнительный механизм

Model tree:
1. Операция без истории:1  (labels: Затвор 023F.Z DN600 PN10 под исполнительный механизм)