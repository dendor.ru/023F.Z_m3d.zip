# KOMPAS-3D part "Затвор 023F.Z DN900 PN16 под исполнительный механизм" (çáΓó«α 023F.Z DN900 PN16 »«ñ ¿ß»«½¡¿ΓÑ½∞¡δ⌐ ¼Ñσá¡¿º¼.m3d)
File: written by KOMPAS-3D 19.0; created 25.04.2025 16:57:16, last saved 25.04.2025 16:57:16.

Document properties: Автор: Евгений; Полное имя файла: E:\Dendor Работа Сачек\3D для проекитирвщиков\1.7 Тип 023F.Z Затвор дисковый поворотный фланцевый с двумя эксцентриками\stp_Тип 023F.Z. Затвор под исполн. механизм\Затвор 023F.Z DN900 PN16 под исполнительный механизм.m3d

Product:
- Part/product: Затвор 023F.Z DN900 PN16 под исполнительный механизм

Model tree:
1. Операция без истории:1  (labels: Затвор 023F.Z DN900 PN16 под исполнительный механизм)