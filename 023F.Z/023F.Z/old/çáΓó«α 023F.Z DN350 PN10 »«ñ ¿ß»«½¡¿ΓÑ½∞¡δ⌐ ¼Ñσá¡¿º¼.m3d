# KOMPAS-3D part "Затвор 023F.Z DN350 PN10 под исполнительный механизм" (çáΓó«α 023F.Z DN350 PN10 »«ñ ¿ß»«½¡¿ΓÑ½∞¡δ⌐ ¼Ñσá¡¿º¼.m3d)
File: written by KOMPAS-3D 19.0; created 25.04.2025 16:56:05, last saved 25.04.2025 16:56:05.

Document properties: Автор: Евгений; Полное имя файла: E:\Dendor Работа Сачек\3D для проекитирвщиков\1.7 Тип 023F.Z Затвор дисковый поворотный фланцевый с двумя эксцентриками\stp_Тип 023F.Z. Затвор под исполн. механизм\Затвор 023F.Z DN350 PN10 под исполнительный механизм.m3d

Product:
- Part/product: Затвор 023F.Z DN350 PN10 под исполнительный механизм

Model tree:
1. Операция без истории:1  (labels: Затвор 023F.Z DN350 PN10 под исполнительный механизм)