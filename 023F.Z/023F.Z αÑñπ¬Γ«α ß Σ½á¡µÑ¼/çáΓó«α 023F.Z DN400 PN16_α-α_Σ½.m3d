# KOMPAS-3D part "Затвор 023F.Z DN400 PN16 + редуктор с входным фланцем" (çáΓó«α 023F.Z DN400 PN16_α-α_Σ½.m3d)
File: written by KOMPAS-3D 19.0; created 27.04.2026 13:33:15, last saved 27.04.2026 13:33:15.

Document properties: Полное имя файла: ..\..\Затвор 023F.Z DN200-DN1600_редуктор с входным фланцем\Затвор 023F.Z DN400 PN16 + редуктор с входным фланцем.a3d

Product:
- Part/product: Затвор 023F.Z DN400 PN16 + редуктор с входным фланцем
    Масса: 197.419

Model tree:
1. Операция без истории:1