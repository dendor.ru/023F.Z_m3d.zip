# KOMPAS-3D part "Затвор 023F.Z DN700 PN10 + редуктор с входным фланцем" (çáΓó«α 023F.Z DN700 PN10_α-α_Σ½.m3d)
File: written by KOMPAS-3D 19.0; created 27.04.2026 13:35:26, last saved 27.04.2026 13:35:26.

Document properties: Полное имя файла: ..\..\Затвор 023F.Z DN200-DN1600_редуктор с входным фланцем\Затвор 023F.Z DN700 PN10 + редуктор с входным фланцем.a3d

Product:
- Part/product: Затвор 023F.Z DN700 PN10 + редуктор с входным фланцем
    Масса: 559.033

Model tree:
1. Операция без истории:1