# KOMPAS-3D part "Затвор 023F.Z DN250 PN16 + редуктор с входным фланцем" (çáΓó«α 023F.Z DN250 PN16 + αÑñπ¬Γ«α ß óσ«ñ¡δ¼ Σ½á¡µÑ¼.m3d)
File: written by KOMPAS-3D 19.0; created 10.05.2025 17:23:10, last saved 10.05.2025 17:23:10.

Document properties: Полное имя файла: Затвор 023F.Z DN250 PN16 + редуктор с входным фланцем.a3d

Product:
- Part/product: Затвор 023F.Z DN250 PN16 + редуктор с входным фланцем
    Масса: 78.4022

Model tree:
1. Операция без истории:1