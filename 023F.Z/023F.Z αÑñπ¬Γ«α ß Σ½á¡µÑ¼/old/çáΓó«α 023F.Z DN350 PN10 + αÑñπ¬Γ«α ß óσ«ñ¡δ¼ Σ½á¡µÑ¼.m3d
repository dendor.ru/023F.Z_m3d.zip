# KOMPAS-3D part "Затвор 023F.Z DN350 PN10 + редуктор с входным фланцем" (çáΓó«α 023F.Z DN350 PN10 + αÑñπ¬Γ«α ß óσ«ñ¡δ¼ Σ½á¡µÑ¼.m3d)
File: written by KOMPAS-3D 19.0; created 10.05.2025 17:22:04, last saved 10.05.2025 17:22:04.

Document properties: Полное имя файла: Затвор 023F.Z DN350 PN10 + редуктор с входным фланцем.a3d

Product:
- Part/product: Затвор 023F.Z DN350 PN10 + редуктор с входным фланцем
    Масса: 129.514

Model tree:
1. Операция без истории:1