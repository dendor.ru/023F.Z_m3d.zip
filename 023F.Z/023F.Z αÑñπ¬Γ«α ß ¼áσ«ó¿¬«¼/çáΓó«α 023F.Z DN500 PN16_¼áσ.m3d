# KOMPAS-3D part "Затвор 023F.Z DN500 PN16 + редуктор с маховиком" (çáΓó«α 023F.Z DN500 PN16_¼áσ.m3d)
File: written by KOMPAS-3D 19.0; created 27.04.2026 14:23:20, last saved 27.04.2026 14:23:20.

Document properties: Полное имя файла: ..\..\Затвор 023F.Z DN200-DN1600_с маховиком\Затвор 023F.Z DN500 PN16 + редуктор с маховиком.a3d

Product:
- Part/product: Затвор 023F.Z DN500 PN16 + редуктор с маховиком
    Масса: 313.797

Model tree:
1. Операция без истории:1