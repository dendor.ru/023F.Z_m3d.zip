# KOMPAS-3D part "Затвор 023F.Z DN1400 PN16 + редуктор с маховиком" (çáΓó«α 023F.Z DN1400 PN16 + αÑñπ¬Γ«α ß ¼áσ«ó¿¬«¼.m3d)
File: written by KOMPAS-3D 19.0; created 12.05.2025 16:49:23, last saved 12.05.2025 16:49:23.

Document properties: Полное имя файла: Затвор 023F.Z DN1400 PN16 + редуктор с маховиком.a3d

Product:
- Part/product: Затвор 023F.Z DN1400 PN16 + редуктор с маховиком
    Масса: 3565.29

Model tree:
1. Операция без истории:1